HEC-RAS study dongsan-ch.prj: dongsan-ch

--- dongsan-ch.g01 (geometry) --- (continued)

Type RM Length L Ch R = 1 ,18      ,50,50,50
#Sta/Elev= 11
     -13    1.23      -3    1.23      -2    2.13       0    2.13     2.4     .93
     2.9    -.27     9.9    -.27    12.9    2.23    13.9    2.23    17.4    -.47
    27.4    -.47
#Mann= 3 , 0 , 0
     -13    .035       0       0    .035       0    12.9    .035       0
#XS Ineff= 2 , 0
               0    2.13    12.9            2.23
Permanent Ineff=
       F       F
Bank Sta=0,12.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,17      ,50,50,50
#Sta/Elev= 11
     -13     .71      -3     .71      -2    2.11       0    2.11     2.4     .91
     2.9    -.29     9.9    -.29    12.9    2.21    13.9    2.21    17.4    -.49
    27.4    -.49
#Mann= 3 , 0 , 0
     -13    .035       0       0    .035       0    12.9    .035       0
#XS Ineff= 2 , 0
               0    2.11    12.9            2.21
Permanent Ineff=
       F       F
Bank Sta=0,12.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,16      ,50,50,50
#Sta/Elev= 11
     -13     .27      -3     .27      -2    2.07       0    2.07     2.4     .87
     2.9    -.33     9.9    -.33    12.9    2.17    13.9    2.17    17.4    -.53
    27.4    -.53
#Mann= 3 , 0 , 0
     -13    .035       0       0    .035       0    12.9    .035       0
#XS Ineff= 2 , 0
               0    2.07    12.9            2.17
Permanent Ineff=
       F       F
Bank Sta=0,12.9
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,15      ,50,50,50
#Sta/Elev= 11
     -13     .32      -3     .32      -2    2.12       0    2.12     2.5     .82
     2.9    -.38     9.4    -.38    12.4    2.12    13.4    2.12    16.9    4.62
    26.9    4.62
#Mann= 3 , 0 , 0
     -13    .035       0       0    .035       0    12.4    .035       0
#XS Ineff= 2 , 0
               0    2.12    12.4            2.12
Permanent Ineff=
       F       F
Bank Sta=0,12.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,14      ,50,50,50
#Sta/Elev= 15
   -28.5    5.17   -18.5    5.17   -15.5    3.67   -10.5    3.67    -7.5    3.37
    -4.5    2.77       0    2.27       3     .57     4.6     .37     5.6    -.43
    11.1    -.43    13.6    1.57    14.6    1.57    16.1    -.43    26.1    -.43
#Mann= 3 , 0 , 0
   -28.5    .035       0       0    .035       0    13.6    .035       0
#XS Ineff= 2 , 0
               0    2.27    13.6            1.57
Permanent Ineff=
       F       F
Bank Sta=0,13.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,13      ,50,50,50
#Sta/Elev= 14
   -28.5    5.13   -18.5    5.13   -15.5    3.63   -10.5    3.63      -9    3.43
      -4    2.63       0    2.13       3     .53     5.5    -.47    10.5    -.47
      13    1.33      14    1.33    15.5    -.17    25.5    -.17
#Mann= 3 , 0 , 0
   -28.5    .035       0       0    .035       0      13    .035       0
#XS Ineff= 2 , 0
               0    2.13      13            1.33
Permanent Ineff=
       F       F
Bank Sta=0,13
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,12      ,50,50,50
#Sta/Elev= 13
   -15.6    -1.1    -5.6    -1.1    -3.6     -.3     -.6     2.2       0     2.2
       3      .2     4.5     -.5     5.5       0    13.5       0    14.5     1.5
    19.5     1.5      20       1      30       1
#Mann= 3 , 0 , 0
   -15.6    .035       0       0    .035       0    14.5    .035       0
#XS Ineff= 2 , 0
               0     2.2    14.5             1.5
Permanent Ineff=
       F       F
Bank Sta=0,14.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,11      ,50,50,50
#Sta/Elev= 13
   -15.6    -.17    -5.6    -.17    -3.6     .63     -.6    3.13       0    3.13
       3     .93     4.5    -.07     5.5    -.57    11.5    -.57    12.5     .93
    16.5     .93      17     .43      27     .43
#Mann= 3 , 0 , 0
   -15.6    .035       0       0    .035       0    12.5    .035       0
#XS Ineff= 2 , 0
               0    3.13    12.5             .93
Permanent Ineff=
       F       F
Bank Sta=0,12.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,10      ,50,50,50
#Sta/Elev= 13
   -15.6    -.23    -5.6    -.23    -3.6     .57     -.6    3.07       0    3.07
     2.3     .87     3.8    -.13     4.8    -.63     8.3    -.63     9.3     .87
    11.8     .87    12.3     .37    22.3     .37
#Mann= 3 , 0 , 0
   -15.6    .035       0       0    .035       0     9.3    .035       0
#XS Ineff= 2 , 0
               0    3.07     9.3             .87
Permanent Ineff=
       F       F
Bank Sta=0,9.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,9       ,50,50,50
#Sta/Elev= 13
   -15.6    -.13    -5.6    -.13    -3.6     .67     -.6    3.17       0    3.17
     2.3     .97     3.8    -.03     4.8    -.53     8.3    -.53     9.8     .97
    11.8     .97    12.3     .47    22.3     .47
#Mann= 3 , 0 , 0
   -15.6    .035       0       0    .035       0     9.8    .035       0
#XS Ineff= 2 , 0
       0       0    3.17     9.8       0     .97
Permanent Ineff=
       F       F
Bank Sta=0,9.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,8       ,31,31,31
#Sta/Elev= 9
   -15.6    -.04    -5.6    -.04    -3.6     .76     -.6    3.26       0    3.26
     2.3    1.06     3.8     .06     4.8    -.44    14.8    -.44
#Mann= 3 , 0 , 0
   -15.6    .035       0     -.6    .035       0       0    .035       0
#XS Ineff= 2 , 0
             -.6    3.26       0            3.26
Permanent Ineff=
       F       F
Bank Sta=-.6,0
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,7.019   ,19,19,19
#Sta/Elev= 12
     -25    4.39     -15    4.39     -12    3.09       0    3.09       5     .89
     8.5     .39      10    -.41      15    -.41      18    1.59    19.5    1.59
    21.7    -.01    31.7    -.01
#Mann= 3 , 0 , 0
     -25    .035       0       0    .035       0      18    .035       0
#XS Ineff= 2 , 0
               0    3.09      18            1.59
Permanent Ineff=
       F       F
Bank Sta=0,18
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,7       ,50,50,50
#Sta/Elev= 13
     -20    2.26     -10    2.26      -5    1.46       0    1.46       3     .76
       6    -.14      10     .46      14    -.54    17.5    -.54    21.5    1.46
    22.5    1.46    26.5    3.96    36.5    3.96
#Mann= 3 , 0 , 0
     -20    .035       0     -10    .035       0    26.5    .035       0
#XS Ineff= 2 , 0
       0     -10    2.26    26.5       0    3.96
Permanent Ineff=
       F       F
Bank Sta=-10,26.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,6       ,50,50,50
#Sta/Elev= 14
     -16    2.71      -6    2.71      -3    2.01       0    2.01       3    1.41
       6     .41     9.5    1.21    12.5     .51    13.7    -.69    17.2    -.69
    21.2    1.81    22.2    1.81    26.4    4.51    36.4    4.51
#Mann= 3 , 0 , 0
     -16    .035       0      -6    .035       0    26.4    .035       0
#XS Ineff= 2 , 0
       0      -6    2.71    26.4       0    4.51
Permanent Ineff=
       F       F
Bank Sta=-6,26.4
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,5       ,50,50,50
#Sta/Elev= 11
     -23    3.69     -13    3.69      -8    3.09      -3    2.69       0    1.69
     3.2    -.51     8.2    -.51    11.2    1.49    12.2    1.49    15.3    -.71
    25.3    -.71
#Mann= 3 , 0 , 0
     -23    .035       0     -13    .035       0    11.2    .035       0
#XS Ineff= 2 , 0
       0     -13    3.69    11.2       0    1.49
Permanent Ineff=
       F       F
Bank Sta=-13,11.2
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,4       ,50,50,50
#Sta/Elev= 13
   -25.2    3.67   -15.2    3.67   -10.2    3.07    -7.2    3.07    -3.2    2.67
      -2    2.27       0    1.67       3    -.33      10    -.33      13    1.87
      14    1.87    17.2    -.43    27.2    -.43
#Mann= 3 , 0 , 0
   -25.2    .035       0   -15.2    .035       0      13    .035       0
#XS Ineff= 2 , 0
       0   -15.2    3.67      13       0    1.87
Permanent Ineff=
       F       F
Bank Sta=-15.2,13
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,3       ,50,50,50
#Sta/Elev= 12
   -17.5    2.99    -7.5    2.99    -2.5    2.39       0    2.39       4    1.79
      10     .59    12.8    -.31    20.3    -.31    23.3    1.99    24.3    1.99
    27.5    -.31    37.5    -.31
#Mann= 3 , 0 , 0
   -17.5    .035       0    -7.5    .035       0    23.3    .035       0
#XS Ineff= 2 , 0
       0    -7.5    2.99    23.3       0    1.99
Permanent Ineff=
       F       F
Bank Sta=-7.5,23.3
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,2       ,50,50,50
#Sta/Elev= 13
    -3.4   11.37    -1.4    6.37       0    2.87      .6    1.37    10.6    1.37
    13.3     .57    14.1     .57    15.8    -.43    21.8    -.43    24.8    1.77
    25.8    1.77      29    -.53      39    -.53
#Mann= 3 , 0 , 0
    -3.4    .035       0    10.6    .035       0    24.8    .035       0
#XS Ineff= 2 , 0
            10.6    1.37    24.8            1.77
Permanent Ineff=
       F       F
Bank Sta=10.6,24.8
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,1       ,50,50,50
#Sta/Elev= 15
    -6.7   17.46    -4.7   13.46    -2.7    9.46     -.7    5.46       0    4.06
     1.3    1.46    11.3    1.46    14.1     .56    14.9     .56    16.6    -.44
    22.6    -.44    25.6    1.56    26.6    1.56    29.7    -.64    39.7    -.64
#Mann= 3 , 0 , 0
    -6.7    .035       0    11.3    .035       0    25.6    .035       0
#XS Ineff= 2 , 0
            11.3    1.46    25.6            1.56
Permanent Ineff=
       F       F
Bank Sta=11.3,25.6
XS Rating Curve= 0
Exp/Cntr=.3,.1

Type RM Length L Ch R = 1 ,0       ,0,0,0
#Sta/Elev= 11
     -10    5.24       0    5.24       3    1.24       5     .74      15     .74
      21     .04      21    -.46    28.5    -.46    28.5    5.34    35.5   10.34
    45.5   10.34
#Mann= 3 , 0 , 0
     -10    .035       0       0    .035       0    28.5    .035       0
#XS Ineff= 2 , 0
               0    5.24    28.5            5.34
Permanent Ineff=
       F       F
Bank Sta=0,28.5
XS Rating Curve= 0
Exp/Cntr=.3,.1

Chan Stop Cuts=-1
